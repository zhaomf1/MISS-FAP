# Keil uVision project miss-fap.uvprojx, settings and files
target miss-fap (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80DFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: miss-fap +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ../Core/Inc;../Core/Inc/app;../Core/Inc/common;../Core/Inc/peripheral;../Core/Inc/system;../Core/Src/font;../Middleware/LVGL;../Middleware/LVGL/include;../Middleware/LVGL/src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  asm include: ../Core/Inc;../Core/Inc/app;../Core/Inc/common;../Core/Inc/peripheral;../Core/Inc/system;../Middleware/LVGL;../Middleware/LVGL/include;../Middleware/LVGL/src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xE0000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core/App
    ../Core/Src/app/: main.c motor.c key.c lcd_st7789.c lvgl_port.c dev_temp_ctrl.c ui_layout.c incubator_model.c temp_calibration.c temp_service.c app_service.c
    ../Core/Src/font/: lv_font_ui_font.c
  group Application/User/Core/Common
    ../Core/Src/common/: modbus_rtu.c protocol_slave.c
  group Application/User/Core/Peripheral
    ../Core/Src/peripheral/: rs485_port.c gpio.c freertos.c dma.c i2c.c iwdg.c bsp_board_io.c spi.c tim.c usart.c
  group Application/User/Core/System
    ../Core/Src/system/: stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Middleware/LVGL
    ../Middleware/LVGL/src/: lv_init.c
    ../Middleware/LVGL/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_observer.c lv_refr.c
    ../Middleware/LVGL/src/debugging/monkey/: lv_monkey.c
    ../Middleware/LVGL/src/debugging/profiler/: lv_profiler_builtin_posix.c lv_profiler_builtin.c
    ../Middleware/LVGL/src/debugging/sysmon/: lv_sysmon.c
    ../Middleware/LVGL/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../Middleware/LVGL/src/display/: lv_display.c
    ../Middleware/LVGL/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c lv_draw.c
    ../Middleware/LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../Middleware/LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Middleware/LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Middleware/LVGL/src/draw/snapshot/: lv_snapshot.c
    ../Middleware/LVGL/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c lv_draw_sw.c
    ../Middleware/LVGL/src/draw/sw/blend/: lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../Middleware/LVGL/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../Middleware/LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Middleware/LVGL/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Middleware/LVGL/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../Middleware/LVGL/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14_aligned.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../Middleware/LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../Middleware/LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Middleware/LVGL/src/font/font_manager/: lv_font_manager_recycle.c lv_font_manager.c
    ../Middleware/LVGL/src/font/imgfont/: lv_imgfont.c
    ../Middleware/LVGL/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../Middleware/LVGL/src/fs/: lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs.c
    ../Middleware/LVGL/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_lodepng.c lv_tjpgd.c
    ../Middleware/LVGL/src/image/svg/: lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c lv_svg.c
    ../Middleware/LVGL/src/indev/: lv_gridnav.c lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
    ../Middleware/LVGL/src/layouts/: lv_layout.c
    ../Middleware/LVGL/src/layouts/flex/: lv_flex.c
    ../Middleware/LVGL/src/layouts/grid/: lv_grid.c
    ../Middleware/LVGL/src/logging/: lv_log.c
    ../Middleware/LVGL/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi_common.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
    ../Middleware/LVGL/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../Middleware/LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middleware/LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middleware/LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os.c
    ../Middleware/LVGL/src/stdlib/: lv_mem.c
    ../Middleware/LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middleware/LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middleware/LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middleware/LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middleware/LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middleware/LVGL/src/themes/: lv_theme.c
    ../Middleware/LVGL/src/themes/default/: lv_theme_default.c
    ../Middleware/LVGL/src/themes/mono/: lv_theme_mono.c
    ../Middleware/LVGL/src/themes/simple/: lv_theme_simple.c
    ../Middleware/LVGL/src/tick/: lv_tick.c
    ../Middleware/LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middleware/LVGL/src/widgets/animimage/: lv_animimage.c
    ../Middleware/LVGL/src/widgets/arc/: lv_arc.c
    ../Middleware/LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../Middleware/LVGL/src/widgets/bar/: lv_bar.c
    ../Middleware/LVGL/src/widgets/barcode/: lv_barcode.c
    ../Middleware/LVGL/src/widgets/button/: lv_button.c
    ../Middleware/LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middleware/LVGL/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../Middleware/LVGL/src/widgets/canvas/: lv_canvas.c
    ../Middleware/LVGL/src/widgets/chart/: lv_chart.c
    ../Middleware/LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../Middleware/LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../Middleware/LVGL/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../Middleware/LVGL/src/widgets/gif/: lv_gif.c
    ../Middleware/LVGL/src/widgets/gstreamer/: lv_gstreamer.c
    ../Middleware/LVGL/src/widgets/image/: lv_image.c
    ../Middleware/LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middleware/LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../Middleware/LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../Middleware/LVGL/src/widgets/label/: lv_label.c
    ../Middleware/LVGL/src/widgets/led/: lv_led.c
    ../Middleware/LVGL/src/widgets/line/: lv_line.c
    ../Middleware/LVGL/src/widgets/list/: lv_list.c
    ../Middleware/LVGL/src/widgets/lottie/: lv_lottie.c
    ../Middleware/LVGL/src/widgets/menu/: lv_menu.c
    ../Middleware/LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../Middleware/LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middleware/LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Middleware/LVGL/src/widgets/qrcode/: lv_qrcode.c
    ../Middleware/LVGL/src/widgets/roller/: lv_roller.c
    ../Middleware/LVGL/src/widgets/scale/: lv_scale.c
    ../Middleware/LVGL/src/widgets/slider/: lv_slider.c
    ../Middleware/LVGL/src/widgets/span/: lv_span.c
    ../Middleware/LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../Middleware/LVGL/src/widgets/spinner/: lv_spinner.c
    ../Middleware/LVGL/src/widgets/switch/: lv_switch.c
    ../Middleware/LVGL/src/widgets/table/: lv_table.c
    ../Middleware/LVGL/src/widgets/tabview/: lv_tabview.c
    ../Middleware/LVGL/src/widgets/textarea/: lv_textarea.c
    ../Middleware/LVGL/src/widgets/tileview/: lv_tileview.c
    ../Middleware/LVGL/src/widgets/win/: lv_win.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
